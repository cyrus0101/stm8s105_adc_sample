# IAR project stm8s105k4t.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: lib\inc; lib\src; $PROJ_DIR$; BSP
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8s105k4t.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_conf.h
  group BSP
    BSP/: bsp_ADC.c bsp_task.c bsp_time2.c bsp_uart2.c
    lib/src/: stm8s_itc.c
  group lib
    lib/src/: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_tim2.c stm8s_uart2.c
